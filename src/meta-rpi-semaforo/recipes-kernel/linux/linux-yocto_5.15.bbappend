# Añadir fragmento de kernel
FILESEXTRAPATHS := "${THISDIR}/files:${FILESEXTRAPATHS}"

SRC_URI += "file://linux-yocto-camera.cfg"
