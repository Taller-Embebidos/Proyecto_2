PACKAGECONFIG:append = " dnn"
