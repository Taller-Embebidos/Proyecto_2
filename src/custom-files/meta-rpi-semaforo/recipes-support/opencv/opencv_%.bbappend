PACKAGECONFIG:append = " gtk dnn"
